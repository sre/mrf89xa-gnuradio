options:
  parameters:
    author: Sebastian Reichel
    description: MRF89XA Transceiver
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: 868.46e6
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: 24 - 6
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: rx_samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: samp_rate / baud_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: squelch_threshold
  id: variable
  parameters:
    value: '-55'
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.9'
    gate: 'False'
    ramp: '0'
    threshold: squelch_threshold
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*3.14*fsk_deviation_hz)
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 120e3
    low_cutoff_freq: 80e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(samp_per_sym)
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '0.7'
    comment: VCO Sensitivity = (2 * Pi * MAX_FREQ / MAX_INPUT_VAL)
    samp_rate: baud_rate*samp_per_sym
    sensitivity: 2*3.14*fsk_deviation_hz
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_per_sym
    ted_gain: '0.5'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 200e3
    decim: int(rx_samp_rate / samp_rate)
    gain: '1'
    samp_rate: rx_samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: baud_rate
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: baud_rate
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: packet_len
    port: '7000'
    type: UDP_CLIENT
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '24'
    port: '7001'
    type: UDP_SERVER
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: '"RX"'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: tx_samp_rate
    fc: 866e6
    fftsize: '1024'
    name: '"TX out"'
    type: complex
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: int(baud_rate*samp_per_sym)
    interp: int(tx_samp_rate)
    taps: ''
    type: ccc
  states: {}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    comment: 0xaa 0xaa 0xf0 0x0f 0x12 0xed
    packlen: packet_len
    sync: '"101010101010101011110000000011110001001011101101"'
    threshold: '1'
  states: {}
- name: soapy_sink_0
  id: soapy_sink
  parameters:
    ant0: BAND1
    center_freq0: freq
    devname: lime
    iamp_gain0: '1.0'
    manual_gain0: 'False'
    overall_gain0: '32'
    pad_gain0: '1.0'
    pga_gain0: '1.0'
    samp_rate: tx_samp_rate
    type: fc32
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    ant0: LNAL
    balance0: '0'
    center_freq0: freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'True'
    devname: lime
    overall_gain0: '0'
    samp_rate: rx_samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: RX
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: demod
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: TXdata
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: RX
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: demod
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: TXdata
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', virtual_sink_0, '0']
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0_0, '0']
- [band_pass_filter_0, '0', rational_resampler_xxx_1_0, '0']
- [blocks_add_const_vxx_0, '0', virtual_sink_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_repeat_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_repeat_0, '0']
- [blocks_vco_c_0, '0', band_pass_filter_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_sync_to_pdu_packed_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0_0, '0', virtual_sink_0_0, '0']
- [network_socket_pdu_0_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [rational_resampler_xxx_1_0, '0', qtgui_waterfall_sink_x_1, '0']
- [rational_resampler_xxx_1_0, '0', soapy_sink_0, '0']
- [satellites_sync_to_pdu_packed_0, out, network_socket_pdu_0, pdus]
- [soapy_source_0, '0', low_pass_filter_0, '0']
- [virtual_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [virtual_source_0_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_1, '0', blocks_vco_c_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
